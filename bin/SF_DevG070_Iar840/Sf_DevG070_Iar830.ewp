# IAR project Sf_DevG070_Iar830.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070CB ST STM32G070CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\source\pub; ..\..\source\application\demo_application\include; ..\..\source\cpus\STM32G0XXX\include; ..\..\source\products\Sf_DevBrd_G07x\include; ..\..\source\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\source\Interface\Inc; ..\..\source\Core\Inc; ..\..\source\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sf_DevG070_Iar830.hex
  ILINK.IlinkOutputFile: Sf_DevG070_Iar830.out
  ILINK.IlinkIcfFile: Cpu_resource_cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Core/Src
    ../../source/Core/Src/: Application.c Application_Data.c boardctrl.c demo_app.c HMI_Proc.c Main.c serialProc.c stm32f0xx_vector.c system_stm32g0xx.c
  group Core/Startup
    ../../source/Core/Startup/: startup_stm32f0xx.s
  group Drives/STM32G0xx_HAL_Driver/Src
    ../../source/Drivers/STM32G0xx_HAL_Driver/Src/: stm32f10x_iwdg.c stm32f10xx_systick.c Stm32g0xx_flash.c stm32g0xx_hal_dma.c stm32g0xx_hal_rcc.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c Stm32g0xxx_adc.c
  group Interface/Lib
    ../../source/Interface/Lib/: stm32g070cbt6_st_lib_Rx_Pa9_CoTmLimit 20220409 Iar 8.40.2 V 1.04.a
  group Interface/Src
    ../../source/Interface/Src/: App_Api.c buffer.c comm_service.c common_driver.c common_media.c ctrl_service.c Knx_InternalData.c Knx_Mem.c Knx_Run.c KnxProp_0705.c math_service.c mem_malloc.c
